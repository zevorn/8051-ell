# Keil uVision project project.uvproj, settings and files
target STC8x (MCS-51)
  device: STC8C2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project_STC8x +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\libraries;..\..\libraries\core;..\..\libraries\core\register\STC8x;..\..\libraries\core\startup\STC8x;..\..\libraries\peripherals;..\..\libraries\peripherals\STC8x\inc;..\..\libraries\peripherals\STC8x\src;.\main;.\application
  link misc: REMOVEUNUSED
  group lib/startup
    ../../libraries/core/startup/STC8x/: startup_stc8g.s
  group lib/core
    ../../libraries/core/: ELL_CORE.h ELL_TYPE.h
  group lib/peripherals
    ../../libraries/peripherals/: PerList.h
    ../../libraries/peripherals/STC8x/src/: STC8x_COMP.c STC8x_EEPROM.c STC8x_GPIO.c STC8x_I2C.c STC8x_POWER.c STC8x_RST.c STC8x_SPI.c STC8x_SYSCLK.c STC8x_TIMER.c STC8x_UART.c STC8x_WDT.c STC8x_MDU16.c STC8x_DELAY.c
  group user/main
    ./main/: ELL_CFG.h main.c init.c isr.c
