# Keil uVision project project.uvproj, settings and files
target STC8x (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: output +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\libraries;..\..\libraries\core;..\..\libraries\core\register\STC8x;..\..\libraries\drives;..\..\libraries\drives\KeyScan;..\..\libraries\peripherals;..\..\libraries\peripherals\STC8x\inc;..\..\libraries\peripherals\STC8x\src;..\..\libraries\components;..\..\libraries\components\TMT;..\..\libraries\components\PrintfRed;..\..\libraries\components\PreDelay;.\main;.\application;..\..\libraries\core\startup\STC8x;..\..\examples\STC8Ax\example_adc;..\..\examples\STC8Ax\example_exti
  link misc: REMOVEUNUSED
  group lib/startup
    ../../libraries/core/startup/STC8x/: startup_stc8a.s
  group lib/core
    ../../libraries/core/: ELL_CORE.h ELL_TYPE.h
  group lib/peripherals
    ../../libraries/peripherals/: PerList.h
    ../../libraries/peripherals/STC8x/src/: STC8x_DELAY.c STC8x_ADC.c STC8x_COMP.c STC8x_EEPROM.c STC8x_GPIO.c STC8x_I2C.c STC8x_PCA.c STC8x_POWER.c STC8x_PWM.c STC8x_RST.c STC8x_SPI.c STC8x_SYSCLK.c STC8x_TIMER.c STC8x_UART.c STC8x_WDT.c
  group user/main
    ./main/: main.c init.c isr.c
  group user/example
    ../../examples/STC8Ax/example_adc/: example_adc.c
    ../../examples/STC8Ax/example_exti/: example_exti.c
    ../../examples/STC8Ax/example_eeprom/: example_eeprom.c
    ../../examples/STC8Ax/example_pca/: example_pca.c
  group user/app
    ./application/: app.c
