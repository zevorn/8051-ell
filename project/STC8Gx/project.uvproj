# Keil uVision project project.uvproj, settings and files
target STC8x (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: output +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\libraries;..\..\libraries\core;..\..\libraries\core\register\STC8x;..\..\libraries\core\startup\STC8x;..\..\libraries\peripherals;..\..\libraries\peripherals\STC8x\inc;..\..\libraries\peripherals\STC8x\src;.\main;.\application;..\..\examples\STC8Gx\example_adc;..\..\examples\STC8Gx\example_exti;..\..\examples\STC8Gx\example_mpwm
  link misc: REMOVEUNUSED
  group lib/startup
    ../../libraries/core/startup/STC8x/: startup_stc8g.s
  group lib/core
    ../../libraries/core/: ELL_CORE.h ELL_TYPE.h
  group lib/peripherals
    ../../libraries/peripherals/: PerList.h
    ../../libraries/peripherals/STC8x/src/: STC8x_SYSCLK.c STC8x_ADC.c STC8x_EEPROM.c STC8x_COMP.c STC8x_GPIO.c STC8x_I2C.c STC8x_PCA.c STC8x_POWER.c STC8x_RST.c STC8x_SPI.c STC8x_TIMER.c STC8x_UART.c STC8x_WDT.c STC8x_HPWM.c STC8x_MDU16.c STC8x_DELAY.c STC8x_MPWM.c
  group user/main
    ./main/: ELL_CFG.h main.c init.c isr.c
  group user/example
    ../../examples/STC8Gx/example_adc/: example_adc.c
    ../../examples/STC8Gx/example_exti/: example_exti.c
    ../../examples/STC8Gx/example_eeprom/: example_eeprom.c
    ../../examples/STC8Gx/example_mpwm/: example_mpwm.c
